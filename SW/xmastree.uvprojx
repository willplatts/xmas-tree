# Keil uVision project xmastree.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ATSAMD09C13A Microchip
  pack: Keil.SAMD09_DFP.1.0.1
  cpu: IRAM(0x20000000,0x00001000) IROM(0x00000000,0x00002000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: xmastree
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c misc: --cpp11
  c include: C:\Keil_v5\ARM\PACK\ARM\CMSIS\5.4.0\CMSIS\Core\Include
  memory RVCT4: ROM 0x0 size 0x2000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group Source Group 1
    ./: main.c timer.cpp xmastree.h timer.h
software components: Device:Startup 1.0.0
